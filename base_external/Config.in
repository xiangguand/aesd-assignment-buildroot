## base_external/Config.in
```kconfig
source "$BR2_EXTERNAL_Assignment7_PATH/package/aesd-assignments/Config.in"
source "$BR2_EXTERNAL_Assignment7_PATH/package/ldd/Config.in"
```
